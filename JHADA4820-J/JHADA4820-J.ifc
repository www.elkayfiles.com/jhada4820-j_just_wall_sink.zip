Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-01-22T13:12:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 22 13:12:41 2024 * Host: ZIL5CD2317NJM * Database: C:\Users\MKhan\AppData\Local\Temp\f20d803b-ad12-4e08-865e-ad30814a030a\d5c64e19-01c6-4d6f-9f1f-03f26f2d7233\ifc * Database version: 5507 * Database creation date: Mon Jan 22 13:12:41 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 22 13:12:41 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 22 13:12:41 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:1/4" Head, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: JHADA4820-J:JHADA4820-J, JHADA4820-J:JHADA4820-J:811911
In: Level 1
Type - Material: Metal - Steel - Stainless - Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: JHADA4820-J
Pset_DistributionFlowElementCommon - Reference: JHADA4820-J; sets with these values: 2
